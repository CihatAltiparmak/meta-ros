LICENSE = "BSD-3-Clause"

ROS_EXEC_DEPENDS += "urdf-parser-plugin"