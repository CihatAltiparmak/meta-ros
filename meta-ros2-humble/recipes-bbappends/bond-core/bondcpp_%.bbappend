# Copyright (c) 2021 LG Electronics, Inc.

inherit pkgconfig

DEPENDS += "rosidl-adapter"
